# IAR project Project.ewp, settings and files
configuration STM32F469-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32F469NI ST STM32F469NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F469xx; USE_STM32469I_DISCO_REVC; EW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565; EW_SURFACE_ROTATION=0; EW_USE_OPERATING_SYSTEM=1
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\ThirdParty\STM32Cube_FW_F4\Drivers\CMSIS\Include; ..\..\..\ThirdParty\STM32Cube_FW_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\ThirdParty\STM32Cube_FW_F4\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\ThirdParty\STM32Cube_FW_F4\Drivers\BSP\STM32469I-Discovery; ..\..\..\ThirdParty\STM32Cube_FW_F4\Drivers\BSP\Components\Common; ..\..\..\ThirdParty\STM32Cube_FW_F4\Drivers\BSP\Components\otm8009a; ..\..\..\ThirdParty\STM32Cube_FW_F4\Drivers\BSP\Components\nt35510; ..\..\Source; ..\..\..\TargetSpecific; ..\..\..\TargetSpecific\Drivers; ..\..\GeneratedCode; ..\..\..\PlatformPackage\RTE; ..\..\GeneratedCode\EmWiGfxInclude; ..\..\..\ThirdParty\STM32Cube_FW_F4\MiddleWares\Third_Party\FreeRTOS\Source\include; ..\..\..\ThirdParty\STM32Cube_FW_F4\MiddleWares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\ThirdParty\STM32Cube_FW_F4\MiddleWares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Source
  OBJCOPY.OOCOutputFile: EmbeddedWizard-STM32F469-Discovery.hex
  ILINK.IlinkOutputFile: EmbeddedWizard-STM32F469-Discovery.out
  ILINK.IlinkIcfFile: stm32f469xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../GeneratedCode/: ewfiles.ipcf
  group Application
    ../../Source/: DeviceDriver.c ewconfig.h ewmain.c main.c
    ./: startup_stm32f469xx.s
  group Application/TargetSpecific
    ../../../TargetSpecific/: ew_bsp_clock.c ew_bsp_display.c ew_bsp_event.c ew_bsp_graphics.c ew_bsp_inout.c ew_bsp_console.c ew_bsp_os.c ew_bsp_system.c ew_bsp_touch.c stm32f4xx_it.c system_stm32f4xx.c
  group Application/TargetSpecific/Drivers
    ../../../TargetSpecific/Drivers/: ft6x06.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../ThirdParty/STM32Cube_FW_F4/Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../ThirdParty/STM32Cube_FW_F4/Drivers/BSP/Components/nt35510/: nt35510.c
  group Drivers/BSP/STM32F469I_Discovery
    ../../../ThirdParty/STM32Cube_FW_F4/Drivers/BSP/STM32469I-Discovery/: stm32469i_discovery.c stm32469i_discovery_lcd.c stm32469i_discovery_qspi.c stm32469i_discovery_sdram.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../ThirdParty/STM32Cube_FW_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c
  group EmbeddedWizard/GeneratedCode
    ../../GeneratedCode/: Application.c Core.c Effects.c Graphics.c Resources.c Views.c
  group EmbeddedWizard/RGB565
    ../../../PlatformPackage/RGB565/: ewextgfx.c libewgfx-m4-iar.a
  group EmbeddedWizard/RTE
    ../../../PlatformPackage/RTE/: ewextrte.c libewrte-m4-iar.a
  group FreeRTOS
    ../../../ThirdParty/STM32Cube_FW_F4/MiddleWares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../ThirdParty/STM32Cube_FW_F4/MiddleWares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../ThirdParty/STM32Cube_FW_F4/MiddleWares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/STM32Cube_FW_F4/MiddleWares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
