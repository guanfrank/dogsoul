# Keil uVision project Project.uvprojx, settings and files
target STM32F469-Discovery (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x50000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EmbeddedWizard-STM32F469-Discovery +hex
  c flags: Optim=3 oTime=1 OneElfS=1 v6Lang=4 wLevel=3
  c define: USE_HAL_DRIVER STM32F469xx USE_STM32469I_DISCO_REVC EW_USE_OPERATING_SYSTEM=1
  c include: ../Inc;..\..\..\ThirdParty\STM32Cube_FW_F4/Drivers/CMSIS/Device/ST/STM32F4xx/Include;..\..\..\ThirdParty\STM32Cube_FW_F4/Drivers/STM32F4xx_HAL_Driver/Inc;..\..\..\ThirdParty\STM32Cube_FW_F4/Drivers/BSP/STM32469I-Discovery;..\..\..\ThirdParty\STM32Cube_FW_F4/Drivers/BSP/Components;..\..\..\ThirdParty\STM32Cube_FW_F4\Drivers/CMSIS/Include;..\..\..\TargetSpecific;..\..\..\TargetSpecific\Drivers;..\..\GeneratedCode;..\..\Source;..\..\..\ThirdParty\STM32Cube_FW_F4\MiddleWares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\ThirdParty\STM32Cube_FW_F4\MiddleWares\Third_Party\FreeRTOS\Source\include;..\..\..\ThirdParty\STM32Cube_FW_F4\MiddleWares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\STM32469I-DISCOVERY.sct
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32469I-DISCOVERY
    ../../../ThirdParty/STM32Cube_FW_F4/Drivers/BSP/STM32469I-Discovery/: stm32469i_discovery_lcd.c stm32469i_discovery.c stm32469i_discovery_sdram.c stm32469i_discovery_qspi.c
    ../../../ThirdParty/STM32Cube_FW_F4/Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../ThirdParty/STM32Cube_FW_F4/Drivers/BSP/Components/nt35510/: nt35510.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../ThirdParty/STM32Cube_FW_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_ll_fmc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_spi.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_qspi.c
  group EmWi/TargetSpecific
    ../../../TargetSpecific/: ew_bsp_graphics.c ew_bsp_clock.c ew_bsp_display.c ew_bsp_event.c ew_bsp_inout.c ew_bsp_console.c ew_bsp_os.c ew_bsp_system.c ew_bsp_touch.c stm32f4xx_it.c system_stm32f4xx.c
    ../../../TargetSpecific/Drivers/: ft6x06.c
  group EmWi/Application
    ./: startup_stm32f469xx.s
    ../../Source/: main.c DeviceDriver.c ewmain.c ewconfig.h
  group FreeRTOS
    ../../../ThirdParty/STM32Cube_FW_F4/MiddleWares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/STM32Cube_FW_F4/MiddleWares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../ThirdParty/STM32Cube_FW_F4/MiddleWares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
    ../../../ThirdParty/STM32Cube_FW_F4/MiddleWares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
software components: Graphics:Embedded Wizard:New Project... 1.0.0
